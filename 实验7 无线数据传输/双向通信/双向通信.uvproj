# Keil uVision project 双向通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 双向通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd.c lcd.h main.c nrf24l01.c nrf24l01.h XPT2046.c XPT2046.h
