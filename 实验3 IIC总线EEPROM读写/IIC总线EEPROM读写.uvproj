# Keil uVision project IIC总线EEPROM读写.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: IIC总线EEPROM读写 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: i2c.c i2c.h main.c
